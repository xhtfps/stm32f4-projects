# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target VirtualCOMPort (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: VirtualCOMPort +hex
  c flags: Optim=2 v6Lang=1 v6LangP=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3;..\CMSIS\CM3\CORE;..\CMSIS\CM3\STARTUP;..\CMSIS\STM32LIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\USB\USBLIB\inc;..\USB\Mass_Storage\inc;..\HARDWARE;..\HARDWARE\LED;..\HARDWARE\tft;..\Com-Rule;..\HARDWARE\AD9834;..\HARDWARE\AD9851;..\HARDWARE\AD9854;..\HARDWARE\AD9954;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\AD9833;..\HARDWARE\DAC7811;..\HARDWARE\KEY;..\HARDWARE\AD5444;..\Soft\Task;..\HARDWARE\DAC8552;..\HARDWARE\MCP410XX;..\HARDWARE\PE4302;..\HARDWARE\ADF4351;..\HARDWARE\ad9910;..\HARDWARE\ad4002;..\HARDWARE\TIMER;..\HARDWARE\AD9959;..\HARDWARE\SETMODE;..\SYSTEM\arm_math;..\HARDWARE\COMMUNICATION
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/CM3/CORE/: core_cm3.c
    ../CMSIS/CM3/: stm32f10x_it.c system_stm32f10x.c
    ../CMSIS/CM3/STARTUP/: startup_stm32f10x_md.s
  group FWLIB
    ../CMSIS/STM32LIB/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c
    ../Soft/Task/: task_manage.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/AD9959/: AD9959.C
    ../HARDWARE/COMMUNICATION/: Communication.c
