//-----------------------------------------------------------------
// 程序描述:
//     AD7606串行SPI读取驱动程序
// 作    者: 凌智电子
// 开始日期: 2017-07-04
// 完成日期: 2009-07-
// 修改日期:
// 版    本: V1.0
// 调试工具: 51单片机;AD7606模数转换模块;1602字符型液晶显示模块(LCM)
// 说    明:
//     (1)调试使用的系统时钟频率Fsysclk=11.0592MHz;
//     (2)PAR/SER/BYTE SEL接高电平，选择串行
//						   AD_CS	 <-- P2^4;						//SPI_CS
// 							 AD_SCLK 	<-- P2^2;					//SPI时钟
// 							 AD_DB7 	--> P3^7;						//SPI_数据
//
// 							 AD_OS0 <-- P1^4;						//过采样模式：0~7 = 无过采样，2倍过采样，4,8,16,32,64，无效
//  						 AD_OS1 <-- P1^5;						//
// 							 AD_OS2 <-- P1^6;						//
// 							 AD_RESET <-- P2^7;					//复位
//  						 AD_BUSY --> P2^0;					//输出繁忙
// 							 AD_CONVSTA <-- P1^7;				//通道1-4开始信号
// 					 		 AD_CONVSTB <-- P2^6;				//通道5-8开始信号
//  						 AD_FRSTDATA --> P2^1;				//数字输出		
//							 PAR/SER/BYTE SEL  		接高电平			DB15接低电平
//
//-----------------------------------------------------------------


//-----------------------------------------------------------------------------
// 头文件包含
//-----------------------------------------------------------------------------
#include <reg52.h>
#include <intrins.h>
#include "ad7606.h"
#include "delay.h"

//-----------------------------------------------------------------
// void AD7606_RST (void)
//-----------------------------------------------------------------
//
// 函数功能: AD7606复位
// 入口参数: 无
// 返回参数: 无
// 全局变量: 无
// 调用模块:    
// 注意事项: 
//     
//-----------------------------------------------------------------
void AD7606_RST(void)
{
	AD_SCLK = 1;
	AD_CS = 1;
	AD_BUSY = 0;
	
	
	AD_RESET = 0;
	AD_RESET = 1;
// 	AD_RESET = 1;		//复位脉冲宽度最小50ns
// 	AD_RESET = 1;
// 	AD_RESET = 1;
	AD_RESET = 0;
}


//-----------------------------------------------------------------
// void AD7606_CONVSTA (void)
//-----------------------------------------------------------------
//
// 函数功能: 启动AD7606转换
// 入口参数: 无
// 返回参数: 无
// 全局变量: 无
// 调用模块: delay_us();   
// 注意事项: 
//     
//-----------------------------------------------------------------
void AD7606_CONVSTA(void)
{
	AD_CONVSTA = 1;
	delay_us(5);
	AD_CONVSTA = 0;
	delay_us(5);
	AD_CONVSTA = 1;
	
	
	AD_CONVSTB = 1;
	delay_us(500);
	AD_CONVSTB = 0;
	delay_us(5);
	AD_CONVSTB = 1;
}



//-----------------------------------------------------------------
// void AD7606_Init (void)
//-----------------------------------------------------------------
//
// 函数功能: AD7606初始化
// 入口参数: 无
// 返回参数: 无
// 全局变量: 无
// 调用模块: AD7606_RST (void) ；AD7606_SETOS();  
// 注意事项: 
//     
//-----------------------------------------------------------------
void AD7606_Init(void)
{

//	AD_FRSTDATA = 0;
	AD7606_SETOS(0);
	AD7606_RST();	
}


//-----------------------------------------------------------------
// void AD7606_SETOS (void)
//-----------------------------------------------------------------
//
// 函数功能: AD7606过采样模式设置
// 入口参数: 过采样模式选择 		0（无过采样）		1（2倍过采样）		2（4倍过采样）		3（8倍过采样）
//														4（16倍过采样）	5（32倍过采样）	6（64倍过采样）	7:无效）
// 返回参数: 无
// 全局变量: 无
// 调用模块:    
// 注意事项: 
//     
//-----------------------------------------------------------------
void AD7606_SETOS(uchar OS)
{
	switch(	OS )	
		{
			case 0: {AD_OS2 = 0; AD_OS1 = 0;AD_OS0 = 0;} break;
			case 1: {AD_OS2 = 0; AD_OS1 = 0;AD_OS0 = 1;} break;
			case 2: {AD_OS2 = 0; AD_OS1 = 1;AD_OS0 = 0;} break;
			case 3: {AD_OS2 = 0; AD_OS1 = 1;AD_OS0 = 1;} break;
			case 4: {AD_OS2 = 1; AD_OS1 = 0;AD_OS0 = 0;} break;
			case 5: {AD_OS2 = 1; AD_OS1 = 0;AD_OS0 = 1;} break;
			case 6: {AD_OS2 = 1; AD_OS1 = 1;AD_OS0 = 0;} break;
			case 7: {AD_OS2 = 1; AD_OS1 = 1;AD_OS0 = 1;} break;
			default:    break; 
		}
}

//-----------------------------------------------------------------
// uint AD7606_Rdata (void)
//-----------------------------------------------------------------
//
// 函数功能: AD7606读取数据
// 入口参数: 无
// 返回参数: rdata为读取的一个通道的16位数据
// 全局变量: 无
// 调用模块:    
// 注意事项: 
//     
//-----------------------------------------------------------------
uint AD7606_Rdata(void)
{
	uint rdata = 0;
	uchar i;
//	if(AD_FRSTDATA == 1)
//	{
		
		AD_CS = 0; 							//片选有效
		for(i=0; i<16; i++)
		{
			AD_SCLK = 0;					//下降沿读数据
			rdata = rdata << 1;
			rdata |= AD_DB7;
			AD_SCLK = 1;	
		}
//	}
	return rdata;		//返回16位数据
}


//-----------------------------------------------------------------
// void AD7606_RCHdata (void)
//-----------------------------------------------------------------
//
// 函数功能: AD7606读取各个通道数据并存放在数组内
// 入口参数: 无
// 返回参数: 无
// 全局变量: 无
// 调用模块: int AD7606_Rdata (void)，AD7606_CONVSTA()    
// 注意事项: 
//     
//-----------------------------------------------------------------
void AD7606_RCHdata(void)
{
	uchar i;
	if( AD_BUSY==0 )  //AD_BUSY为低电平时表示ad处于空闲状态，转换结束
	{
		AD_CS = 0;//片选有效，开始读取数据
//		LED = ~LED;	
//		delay_us(10);
		for(i = 1; i < 9; i++)  //读取8个通道的数据，存入数组
		{
			CH_DATA[i] = AD7606_Rdata();
		}
		AD_CS = 1;   
		AD7606_CONVSTA();   //启动转换开始信号，开始AD转换；
		while(AD_BUSY == 1);     //等待转换完成，方便下次读取；
	}
}

//-----------------------------------------------------------------------------
// End Of File
//-----------------------------------------------------------------------------